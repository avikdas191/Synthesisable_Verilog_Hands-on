# Keil uVision project CubeLab6.uvprojx, settings and files
target CubeLab6 (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: CubeLab6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;        ../Drivers/STM32H7xx_HAL_Driver/Inc;        ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;        ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Benchmarks/Drystone
    ../Core/Benchmarks/Drystone/: dhry_1.c dhry_2.c
  group Benchmarks\Whetstone
    ../Core/Benchmarks/Whetstone/: whetstone.c
  group Benchmarks\CoreMark
    ../Core/Benchmarks/CoreMark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
software components: CMSIS:CORE 5.6.0
