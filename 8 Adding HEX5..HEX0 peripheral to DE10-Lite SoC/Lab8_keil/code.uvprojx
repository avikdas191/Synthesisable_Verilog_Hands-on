# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf -cvf code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf code.axf -o disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0xff
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: cm0dsasm.s
    ./: main.c
software components: CMSIS:CORE 5.1.2
